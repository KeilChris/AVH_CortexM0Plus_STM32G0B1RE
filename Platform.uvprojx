# Keil uVision project Platform.uvprojx, settings and files
target NUCLEO-G0B1RE (6180000::V6.18::ARMCLANG)
  device: STM32G0B1RETx STMicroelectronics
  pack: Keil.STM32G0xx_DFP.1.4.0
  cpu: IRAM(0x20000000,0x00024000) IROM(0x08000000,0x00080000) CPUTYPE("Cortex-M0+") CLOCK(12000000) ELITTLE
  output: image
  c flags: Optim=2 OneElfS=1 uC99=1 uGnu=1 v6Lang=3 v6LangP=3 wLevel=3
  c include: .\Board_IO;.\RTE\Device\STM32G0B1RETx\STCubeGenerated\Inc
  memory RVCT4: ROM 0x8000000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x24000
  scatter file: .\stm32g0b1.sct
  group App
    ./: Platform.c
  group Board IO
    ./Board_IO/: arduino.c arduino.h retarget_stdio.c
  group :STM32CubeMX:Common Sources
    ./RTE/Device/STM32G0B1RETx/STCubeGenerated/Src/: main.c stm32g0xx_it.c
    ./RTE/Device/STM32G0B1RETx/STCubeGenerated/Inc/: stm32g0xx_it.h
  group STM32CubeMX
    ./RTE/Device/STM32G0B1RETx/STCubeGenerated/: STCubeGenerated.ioc
  group Documentation
    ./: README.md
  group Board CMSDK_CM0plus
    ./CMSDK_CM0P_VHT/: main.c main.h retarget_stdio_vht.c
target CMSDK_CM0PLUS_VHT (6180000::V6.18::ARMCLANG)
  device: CMSDK_CM0plus_VHT ARM
  pack: Keil.V2M-MPS2_CMx_BSP.1.8.0
  cpu: IRAM(0x20000000,0x00400000) IROM(0x00000000,0x00400000) CPUTYPE("Cortex-M0+") CLOCK(12000000) ELITTLE
  output: Platform
  c flags: Optim=2 OneElfS=1 uC99=1 uGnu=1 v6Lang=3 v6LangP=3 wLevel=3
  c include: .\CMSDK_CM0P_VHT
  memory RVCT4: ROM 0x0 size 0x400000
  memory RVCT9: RAM 0x20000000 size 0x400000
  scatter file: .\RTE\Device\CMSDK_CM0plus_VHT\ac6_arm.sct
software components: CMSIS Driver:USART:Custom 1.0.0, CMSIS:CORE 5.6.0, CMSIS:RTOS2:Keil RTX5 5.5.4, Test:Unity 2.5.0, Compiler:Event Recorder 1.5.1, Compiler:I/O:STDOUT 1.2.0, Board Support:Drivers:Basic I/O 1.0.0, Board Support:Common 2.0.0, CMSIS Driver:USART 1.0.3, CMSIS Driver:VIO:Board 1.0.0, Device:STM32Cube HAL:Common 1.4.2, Device:STM32Cube HAL:Cortex 1.4.2, Device:STM32Cube HAL:DMA 1.4.2, Device:STM32Cube HAL:GPIO 1.4.2, Device:STM32Cube HAL:PWR 1.4.2, Device:STM32Cube HAL:RCC 1.4.2, Device:STM32Cube HAL:UART 1.4.2, Device:Startup 1.1.0, Device:Startup 1.4.0
